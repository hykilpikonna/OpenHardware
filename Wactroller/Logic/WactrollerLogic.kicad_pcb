# Repository hykilpikonna/OpenHardware

File README.md:

# OpenHardware

在这里会放一些开源硬件的实验作品（还在学习中... qwq

每个作品都有自己的文件夹和说明文档和 license，请看下面的索引：

## Index / 索引

* [Coyote-Pikachu](./Coyote-Pikachu/) 让某电击小盒子变成一只皮卡丘的外壳 ⚡️
* [TaikoStick](./TaikoStick/) 一对可以在任何表面上打太鼓达人的鼓槌 🥁
* [CardReader](./CardReader/) 一个为 SEGA/Bemani 街机音游设计的读卡器固件 💳
* [Sxm2Fan](./Sxm2Fan/) 3D 打印的 V100 SXM2 散热风扇固定器 ❄️
* [YurucampLicensePlate](./YurucampLicensePlate/) 摇曳露营主题车牌框 🏕️

## KiCad design Wactroller/Logic/WactrollerLogic.kicad_pcb

Parts:
BR1, BR2: 5.1k C25905; R0402; LCSC Part C25905
C1: 100pF C1546; C0402; LCSC Part C1546
C2, C8: 1uF C52923; C0402; LCSC Part C52923
C3, C4, C5, C6, C9, C10: 100nF C1525; C0402; LCSC Part C1525
C7: 10uF C15525; C0402; LCSC Part C15525
CAN1: SN65HVD230DR; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; LCSC Part C12084
DCDC1: DCDC
J1: 2.54FH-1x15P-H8.5; HDR-TH_15P-P2.54-V-F; LCSC Part C2932676
JTAG1: 2.54-1*6; HDR-TH_6P-P2.54-V-M; LCSC Part C5156615
LCin1: 10uF C15525; C0402; LCSC Part C15525
LCout1: 100uF C16133; CASE-B_3528; LCSC Part C16133
LDO1: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; LCSC Part C6186
LR1, LR2: 2k C4109; R0402; LCSC Part C4109
LR3: 10k C25744; R0402; LCSC Part C25744
Led1: 0603 Red; LED0603-RD; LCSC Part C2286
Led2: 0603 Yellow; LED0603-RD-YELLOW; LCSC Part C72038
Led3: 0603 Blue; LED0603-RD; LCSC Part C2286
MCU1: ESP32-S2; QFN-56_L7.0-W7.0-P0.40-TL-EP4.0; LCSC Part C529594
NotUSB-Last1: TYPE-C 24P QCHT 143; TYPE-C-USB-SMD_QCHT-143; LCSC Part C5156604
NotUSB-Next1: TYPE-C 24P QCHT 143; TYPE-C-USB-SMD_QCHT-143; LCSC Part C5156604
R1, R3: 10k C25744; R0402; LCSC Part C25744
R2: 120Ω C25079; R0402; LCSC Part C25079
RGB1: XL-1010RGBC-WS2812B; LED-SMD_4P-L1.0-W1.0-TL_XL-1010RGBC-WS2812B; LCSC Part C5349953
USB_C_Board1: MC-126D-DG10; USB-C-SMD_HANBO_MC-126D-DG10; LCSC Part C6332272
X1: 40MHz (15pF) C9010; OSC-SMD_4P-L3.2-W2.5-BL_SIT8008BI; LCSC Part C9010
XC1, XC2: 20pF C1554; C0402; LCSC Part C1554

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, CAN1.3 (VCC), JTAG1.1, LCout1.1, LDO1.2 (VOUT), LDO1.4 (VOUT), MCU1.1 (VDDA), MCU1.3 (VDD3P3), MCU1.4 (VDD3P3), MCU1.20 (VDD3P3_RTC), MCU1.27 (VDD3P3_RTC_IO), MCU1.45 (VDD3P3_CPU), MCU1.51 (VDDA), MCU1.54 (VDDA), R1.2
+5V: DCDC1.4 (V-OUT), J1.2, LCin1.1, LDO1.3 (VIN), LR1.2, LR2.2, LR3.2, RGB1.2 (VDD), USB_C_Board1.A4B9 (VBUS), USB_C_Board1.B4A9 (VBUS)
+28V: DCDC1.2 (V-IN), NotUSB-Last1.A4 (VBUS), NotUSB-Last1.A9 (VBUS), NotUSB-Last1.B4 (VBUS), NotUSB-Last1.B9 (VBUS), NotUSB-Next1.A4 (VBUS), NotUSB-Next1.A9 (VBUS), NotUSB-Next1.B4 (VBUS), NotUSB-Next1.B9 (VBUS)
BCC1: BR1.2, USB_C_Board1.A5 (CC1)
BCC2: BR2.2, USB_C_Board1.B5 (CC2)
BD+: MCU1.26 (GPIO20), USB_C_Board1.A6 (DP1), USB_C_Board1.B6 (DP2)
BD-: MCU1.25 (GPIO19), USB_C_Board1.A7 (DN1), USB_C_Board1.B7 (DN2)
BTN1: J1.12, MCU1.10 (GPIO5)
BTN2: J1.13, MCU1.11 (GPIO6)
BTN3: J1.14, MCU1.12 (GPIO7)
BTN4: J1.15, MCU1.13 (GPIO8)
BTN5: J1.8, MCU1.6 (GPIO1)
BTN6: J1.9, MCU1.7 (GPIO2)
BTN7: J1.10, MCU1.8 (GPIO3)
BTN8: J1.11, MCU1.9 (GPIO4)
BTN9: J1.4, MCU1.14 (GPIO9)
BTN10: J1.5, MCU1.15 (GPIO10)
BTN11: J1.6, MCU1.16 (GPIO11)
BTN12: J1.7, MCU1.17 (GPIO12)
CAN+: CAN1.7 (CANH), NotUSB-Last1.A2 (SSTXp1), NotUSB-Last1.B2 (SSTXp2), NotUSB-Next1.A2 (SSTXp1), NotUSB-Next1.B2 (SSTXp2), R2.2
CAN-: CAN1.6 (CANL), NotUSB-Last1.A3 (SSTXn1), NotUSB-Last1.B3 (SSTXn2), NotUSB-Next1.A3 (SSTXn1), NotUSB-Next1.B3 (SSTXn2), R2.1
CAN-Rs: CAN1.8 (RS), MCU1.21 (XTAL_32K_P), R3.1
CAN-Rx: CAN1.4 (R), MCU1.18 (GPIO13)
CAN-Tx: CAN1.1 (D), MCU1.19 (GPIO14)
EN: MCU1.56 (CHIP_PU), NotUSB-Last1.A11 (SSRXp2), NotUSB-Last1.B11 (SSRXp1), R1.1
GND: BR1.1, BR2.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, CAN1.2 (GND), DCDC1.1 (GND), DCDC1.3 (GND), J1.1, JTAG1.6, LCin1.2, LCout1.2, LDO1.1 (GND), Led3.1 (K), MCU1.57 (GND), NotUSB-Last1.0 (EP), NotUSB-Last1.A1 (GND), NotUSB-Last1.A12 (GND), NotUSB-Last1.B1 (GND), NotUSB-Last1.B12 (GND), NotUSB-Next1.0 (EP), NotUSB-Next1.A1 (GND), NotUSB-Next1.A12 (GND), NotUSB-Next1.B1 (GND), NotUSB-Next1.B12 (GND), R3.2, RGB1.3 (GND), USB_C_Board1.13 (EH), USB_C_Board1.A1B12 (GND), USB_C_Board1.B1A12 (GND), X1.2 (GND), X1.4 (GND), XC1.2, XC2.1
LED: J1.3, MCU1.41 (GPIO37)
LastB0: MCU1.5 (GPIO0), NotUSB-Last1.A10 (SSRXn2), NotUSB-Last1.B10 (SSRXn1)
LastRx: Led2.1 (C), MCU1.49 (U0RXD), NotUSB-Last1.A7 (Dn1), NotUSB-Last1.B7 (Dn2)
LastTx: Led1.1 (K), MCU1.48 (U0TXD), NotUSB-Last1.A6 (Dp1), NotUSB-Last1.B6 (Dp2)
MCU-LED: MCU1.42 (GPIO38), RGB1.4 (DIN)
MUX_S0: MCU1.28 (GPIO21)
unnamed: LR1.1, Led1.2 (A)
unnamed: LR2.1, Led2.2 (A)
unnamed: LR3.1, Led3.2 (A)
NextB0: MCU1.40 (GPIO36), NotUSB-Next1.A10 (SSRXn2), NotUSB-Next1.B10 (SSRXn1)
NextEN: MCU1.39 (GPIO35), NotUSB-Next1.A11 (SSRXp2), NotUSB-Next1.B11 (SSRXp1)
NextRx: MCU1.22 (XTAL_32K_N), NotUSB-Next1.A6 (Dp1), NotUSB-Next1.B6 (Dp2)
NextTx: MCU1.50 (GPIO45), NotUSB-Next1.A7 (Dn1), NotUSB-Next1.B7 (Dn2)
XN: MCU1.52 (XTAL_N), X1.3 (OSC2), XC2.2
XP: MCU1.53 (XTAL_P), X1.1 (OSC1), XC1.1

Notes on the sheet:
For VDDA 1
For V3P3_RTC 20, 27
For V3P3 3, 4
TODO: 加一个请不要插进 USB-C 设备的提示
Power Conversion 28V (3A) → 5V (1.5A) * 10 → 3.3V (<0.5A) * 10
For VDDA 51, 54
Status LED
ESP32 S2 MCU
For V3P3_CPU 45
Connectors
For CAN

Board: 2 copper layers, 60.0 x 50.0 mm, 36 parts (1 on the bottom side), 40 nets.

## Commit log

2023-03-12 [+] Add images
2023-03-12 [+] Add CAD files
2023-03-12 [+] Add readme
2023-03-12 [+] Add pikachu readme
2023-03-12 [O] Change image order
2023-04-20 [+] Taiko project
2023-04-20 [+] Firmware
2023-04-20 [+] Generated files
2023-04-20 [+] Backend reader
2023-04-21 [+] requirements.txt
2023-04-21 [+] Basic documentation
2023-04-21 [F] Fix key timing logic
2023-04-21 [+] Bounce delay
2023-04-21 [U] Rebind key shortcut
2023-04-21 [M] Rename project
2023-04-21 [+] Readme
2023-04-21 [U] Readme add note
2023-04-21 [U] Readme adc protection diode
2023-04-21 [U] Readme: Add pricing info
2023-11-25 [+] Initial version
2023-11-25 [U] Windows winsound support
2023-11-25 [+] Use win32 api for key press
2023-11-25 [U] Update receiver
2023-11-25 [+] Start script
2023-11-25 [F] Fix spicetools not picking up presses
2023-11-25 [M] Move firmware
2023-11-25 [+] PlatformIO
2023-11-25 [+] Libraries
2023-11-25 [+] PN532 Library
2023-11-25 [U] Refactor
2023-11-25 [F] Fix segfault
2023-11-25 [O] Refactor
2023-11-25 [+] RGB!!
2023-11-25 [M] Move files
2023-11-25 [+] Readme docs
2023-11-25 [+] FAQ
2023-11-25 [F] Fix submodules
2023-11-25 [U] Update instructions
2023-11-25 [-] Remove path
2023-11-25 [F] Fix audio path
2023-12-12 [U] Ignore MacOS files
2023-12-12 [+] Create IO4 template
2023-12-13 [+] Keys
2023-12-15 [+] Board config
2023-12-22 [+] Use io4 board config
2023-12-22 [+] Logic Board
2023-12-22 [+] Wactroller Firmware
2023-12-22 [+] FastLED
2023-12-27 [+] Passmark crawling
2023-12-27 [+] GPU data
2023-12-27 [+] CanadaComputers Laptops
2023-12-27 [+] Passmark gpu info
2023-12-27 [+] GPT labeling
2023-12-27 [+] NotebookCheck data
2023-12-27 [-] Remove <sup> tags
2023-12-27 [+] Data analysis
2023-12-27 Create CNAME
2024-05-10 [F] Fix card reader leading 0 error
2024-07-27 [F] Fix waiting too long in loop caused by unlimited retries
2024-07-27 [+] SPI support
2024-08-09 [+] Sxm2 Fan Clip
2024-08-09 [+] Mai touch taiko controller
2026-04-23 [M] Move license
2026-04-23 [-] Remove insignificant projects
2026-04-23 [+] Yurucamp license plate frame
2026-04-23 [O] Clarify
2026-04-23 [O] Image
2026-04-23 [+] Preview
2026-04-25 [+] Baiku ver
